## arch/arm64/configs/lucye_global_ca-perf_defconfig
```kconfig
include lucye_global_ca_common
include lucye_common-perf
CONFIG_USB_HOST_NOTIFY=y
```
